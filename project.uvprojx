# Keil uVision project project.uvprojx, settings and files
target CMSIS-DAP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MKL46Z256xxx4 Freescale
  pack: NXP.MKL46Z4_DFP.10.0.3
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uGnu=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  group src
    ./: main.c slcd.c slcd.h extra.c extra.h nucleo.c nucleo.h i2c0.c i2c0.h
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
